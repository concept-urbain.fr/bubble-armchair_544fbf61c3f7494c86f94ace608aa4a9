Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Bubble Fauteuil.IFC
Time: 2020-06-29T06:56:28
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Assise Bubble 340 V2-D_Default
In: Default Storey
Material: AISI 304L brossé
PSet_Mass_Property - Mass Measure: 30.8244; Area Measure: 1.95885; Volume Measure: 0.00385305

# IfcBeam: BUB-MUL-001-B_Default (2)
In: Default Storey
Material: AISI 304L

# IfcBeam: BUB-MUL-002-D_Default (7)
In: Default Storey
Material: AISI 304L

# IfcBuildingElementProxy: BUB-MUL-001-B_Default (2)
In: Default Storey
Material: AISI 304L

# IfcBuildingElementProxy: BUB-MUL-002-D_Default (40)
In: Default Storey
Material: AISI 304L

# IfcBuildingElementProxy: Socle bubble 340 V2-D_Default
In: Default Storey
Material: AISI 304L brossé
